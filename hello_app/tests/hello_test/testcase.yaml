## hello_app/tests/hello_test/testcase.yaml
```yaml
tests:
  hello.test.sanity:
    platform_allow: native_posix
    tags: hello ci
    integration_platforms:
      - native_posix
```
